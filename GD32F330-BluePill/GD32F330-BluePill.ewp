# IAR project GD32F330-BluePill.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F330x8 GD GD32F330x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __ICCARM__; USE_STDPERIPH_DRIVER; GD32F330; DEBUG; WATCHDOG
  ICCARM.CCDiagSuppress: Pa039, Pe550
  ICCARM.CCIncludePath2: Inc; GD32F3x0_standard_peripheral\Include; GD32F3x0_standard_peripheral\CMSIS\GD\GD32F3x0\Include; GD32F3x0_standard_peripheral\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F330-BluePill-debug.bin
  ILINK.IlinkOutputFile: GD32F330-BluePil-Debug.out
  ILINK.IlinkIcfFile: GD32F330-BluePill.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __ICCARM__; USE_STDPERIPH_DRIVER; GD32F330; WATCHDOG
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: GD32F330-BluePill.bin
  ILINK.IlinkOutputFile: GD32F330-BluePill.out
  group (top)
    ./: GD32F330-BluePill.c GD32F330-BluePill.icf
  group CMSIS/inc
    GD32F3x0_standard_peripheral/CMSIS/: core_cm4.h
  group CMSIS/inc/GD32M4
    GD32F3x0_standard_peripheral/CMSIS/GD/GD32F3x0/Include/: gd32f3x0.h system_gd32f3x0.h
  group Driver
    Drv/: ADC.c CRCCheck.c CycleTime.c delay_uSec.c DMA.c GPIO.c Hardware.c LED.c NVIC.c PVD.c Serial.c SystemIRQ.c Timers.c WDog.c
  group GD StdPerihpLib/Include
    GD32F3x0_standard_peripheral/Include/: gd32f3x0_adc.h gd32f3x0_cec.h gd32f3x0_cmp.h gd32f3x0_crc.h gd32f3x0_ctc.h gd32f3x0_dac.h gd32f3x0_dbg.h gd32f3x0_dma.h gd32f3x0_exti.h gd32f3x0_fmc.h gd32f3x0_fwdgt.h gd32f3x0_gpio.h gd32f3x0_i2c.h gd32f3x0_misc.h gd32f3x0_pmu.h gd32f3x0_rcu.h gd32f3x0_rtc.h gd32f3x0_spi.h gd32f3x0_syscfg.h gd32f3x0_timer.h gd32f3x0_tsi.h gd32f3x0_usart.h gd32f3x0_wwdgt.h
  group GD StdPerihpLib/Source
    GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_crc.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Inc
    Inc/: ADC.h CRCCheck.h CycleTime.h debug.h delay_uSec.h DMA.h gd32f3x0_libopt.h hardware.h ICF_Symbols.h LED.h NVIC.h pindefs.h PVD.h Serial.h Timers.h WDog.h
  group System-Startup
    system-startup/: startup_gd32f3x0.s system_gd32f3x0.c
